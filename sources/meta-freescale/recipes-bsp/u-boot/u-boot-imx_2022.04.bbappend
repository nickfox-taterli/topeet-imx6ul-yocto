FILESEXTRAPATHS:append := "${THISDIR}/files:"

SRC_URI += "file://0001-Add-IMX6UL-TOPEET-Board.patch;md5=12572275a6ecf5bd5131ab90f8141116"
SRC_URI += "file://0002-Force-USB-Device-Mode.patch;md5=4657b4b9a6702d569cf126ebb7d1368d"
SRC_URI += "file://0003-Fix-No-Logo-Display.patch;md5=ec0889b5d055bd8ef28c25c28677a94f"
