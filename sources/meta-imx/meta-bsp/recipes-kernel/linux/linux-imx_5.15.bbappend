FILESEXTRAPATHS:append := "${THISDIR}/files:"

SRC_URI += "file://0001-Add-IMX6UL-TOPEET-Board.patch;md5=0d61ab18cfc4974217db729756603461"
SRC_URI += "file://0002-Fix-mxc-fbdev-cma-alloc.patch;md5=1b4360e85f5ee3b537b41157cbceedb0"
